# IAR project gprsdtu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\cpu; ..\cpu\Libraries; ..\cpu\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\cpu\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\ctkcore; ..\ctkcore\sys; ..\ctkcore\lib; ..\ctkcore\cfs; ..\gprsdtu; ..\gprsdtu\senproto; ..\tools; ..\gprsdtu\spiffs\src; ..\gprsdtu\dev
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gprsdtu.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: D:\Ruhr\Xiongmao\github\DTU1.0\project\gprsdtu.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group cpu
    ../cpu/: clock.c crc.c gpio.c rtc.c rtimer-arch.c usart.c
  group cpu/libraries/stm32lib
    ../cpu/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group cpu/libraries/stm32lib/src
    ../cpu/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ctkcore/lib
    ../ctkcore/lib/: list.c memb.c
  group ctkcore/sys
    ../ctkcore/sys/: etimer.c process.c timer.c
  group gprsdtu
    ../gprsdtu/: battery.c configure.c deviceid.c frameware.c gprs.c logger.c main.c sdcdtu.c senif.c sensor_data_backup.c sevproto.c sim800.c spiffs_disk.c system_status.c usart_stream.c
  group gprsdtu/dev
    ../gprsdtu/dev/: spiflash.c
  group gprsdtu/senproto
    ../gprsdtu/senproto/: senprote-rs3010K.c senprote-t770.c senprote-t800.c senprote-t830.c senprote-water.c senproto-rst460.c senproto-zbm001.c senproto.c
  group gprsdtu/spiffs
    ../gprsdtu/spiffs/src/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c
  group tools
    ../tools/: fifo.c framebuff.c
